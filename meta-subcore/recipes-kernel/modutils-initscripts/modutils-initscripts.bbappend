INITSCRIPT_PARAMS = "start 99 5 ."
