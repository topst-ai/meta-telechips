FEATURES_append = "-subcore"
