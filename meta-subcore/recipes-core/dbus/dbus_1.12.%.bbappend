INITSCRIPT_PARAMS = "start 35 S 3 2 . stop 20 0 1 6 ."
