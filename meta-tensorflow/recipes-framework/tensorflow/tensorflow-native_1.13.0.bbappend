SRC_URI += "file://1001-fix-build-error-third_party-icu-sha256.patch"
