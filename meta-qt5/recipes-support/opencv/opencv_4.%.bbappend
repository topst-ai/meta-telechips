inherit cmake_qt5

EXTRA_OECMAKE += " \
	-DWITH_QT=ON \
"
