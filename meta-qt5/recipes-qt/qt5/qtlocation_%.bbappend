FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
#TODO:Sometimes a geoclue build error has occurred and will be corrected later.
#PACKAGECONFIG_append = "geoclue"
