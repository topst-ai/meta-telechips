X264_DISABLE_ASM_armv7a = "--disable-asm"
