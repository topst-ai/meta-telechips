include libcdk.inc

LIC_FILES_CHKSUM = "file://../audiocodec/include/tcc_audio_interface.h;beginline=1;endline=31;md5=ee857ba4f0e423eaf3df666efd399ce0"
S = "${WORKDIR}/git/demuxer"

