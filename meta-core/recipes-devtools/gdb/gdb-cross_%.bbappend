PACKAGECONFIG ??= "python tui"
