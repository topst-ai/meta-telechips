VIRTUAL-RUNTIME_graphical_init_manager = ""

