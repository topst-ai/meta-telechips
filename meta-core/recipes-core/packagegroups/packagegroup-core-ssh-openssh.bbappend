RDEPENDS_${PN} += "openssh-sftp-server rsync"
