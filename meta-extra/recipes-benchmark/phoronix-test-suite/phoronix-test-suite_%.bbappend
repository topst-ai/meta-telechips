RDEPENDS_${PN} += "packagegroup-core-sdk packagegroup-core-standalone-sdk-target"
RDEPENDS_${PN} += "p7zip yasm nasm flex popt libaio"
