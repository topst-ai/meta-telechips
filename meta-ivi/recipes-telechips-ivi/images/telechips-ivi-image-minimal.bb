# Base this image on generic Telechips IVI image
DESCRIPTION = "This image provides ivi image minimal"

inherit tcc-ivi-image
