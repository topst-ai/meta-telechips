DESCRIPTION = "This image provides ivi image for multimedia"

inherit tcc-ivi-image

IMAGE_INSTALL += " \
    packagegroup-telechips-ivi-multimedia \
"
